# Keil uVision project project.uvprojx, settings and files
target rt-thread (6140000::V6.14::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H750xx, LFS_CONFIG=lfs_config.h, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: applications;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;packages\fal-v0.5.0\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;packages\littlefs-latest;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\utilities\ulog;.\Threadx_to_rt-thread\port;.\Threadx_to_rt-thread\filex\common\inc;.\Threadx_to_rt-thread\filex\ports\cortex_m7\gnu\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    applications/: main.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/drivers/: drv_common.c drv_usart.c drv_gpio.c drv_spi.c drv_sdio.c drv_wlan.c drv_sdram.c drv_lcd.c drv_spi_flash.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.5.0/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group littlefs
    packages/littlefs-latest/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_nor.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
  group FILEX/Souce
    ./Threadx_to_rt-thread/filex/common/src/: fx_directory_attributes_read.c fx_directory_attributes_set.c fx_directory_create.c fx_directory_default_get.c fx_directory_default_get_copy.c fx_directory_default_set.c fx_directory_delete.c fx_directory_entry_read.c fx_directory_entry_write.c fx_directory_exFAT_entry_read.c fx_directory_exFAT_entry_write.c fx_directory_exFAT_free_search.c fx_directory_exFAT_unicode_entry_write.c fx_directory_first_entry_find.c fx_directory_first_full_entry_find.c fx_directory_free_search.c fx_directory_information_get.c fx_directory_local_path_clear.c fx_directory_local_path_get.c fx_directory_local_path_get_copy.c fx_directory_local_path_restore.c fx_directory_local_path_set.c fx_directory_long_name_get.c fx_directory_long_name_get_extended.c fx_directory_name_extract.c fx_directory_name_test.c fx_directory_next_entry_find.c fx_directory_next_full_entry_find.c fx_directory_rename.c fx_directory_search.c fx_directory_short_name_get.c fx_directory_short_name_get_extended.c fx_fault_tolerant_add_bitmap_log.c fx_fault_tolerant_add_checksum_log.c fx_fault_tolerant_add_dir_log.c fx_fault_tolerant_add_FAT_log.c fx_fault_tolerant_apply_logs.c fx_fault_tolerant_calculate_checksum.c fx_fault_tolerant_cleanup_FAT_chain.c fx_fault_tolerant_create_log_file.c fx_fault_tolerant_enable.c fx_fault_tolerant_read_directory_sector.c fx_fault_tolerant_read_FAT.c fx_fault_tolerant_read_log_file.c fx_fault_tolerant_recover.c fx_fault_tolerant_reset_log_file.c fx_fault_tolerant_set_FAT_chain.c fx_fault_tolerant_transaction_end.c fx_fault_tolerant_transaction_fail.c fx_fault_tolerant_transaction_start.c fx_fault_tolerant_write_log_file.c fx_file_allocate.c fx_file_attributes_read.c fx_file_attributes_set.c fx_file_best_effort_allocate.c fx_file_close.c fx_file_create.c fx_file_date_time_set.c fx_file_delete.c fx_file_extended_allocate.c fx_file_extended_best_effort_allocate.c fx_file_extended_relative_seek.c fx_file_extended_seek.c fx_file_extended_truncate.c fx_file_extended_truncate_release.c fx_file_open.c fx_file_read.c fx_file_relative_seek.c fx_file_rename.c fx_file_seek.c fx_file_truncate.c fx_file_truncate_release.c fx_file_write.c fx_file_write_notify_set.c fx_media_abort.c fx_media_boot_info_extract.c fx_media_cache_invalidate.c fx_media_check.c fx_media_check_FAT_chain_check.c fx_media_check_lost_cluster_check.c fx_media_close.c fx_media_close_notify_set.c fx_media_exFAT_format.c fx_media_extended_space_available.c fx_media_flush.c fx_media_format.c fx_media_format_oem_name_set.c fx_media_format_type_set.c fx_media_format_volume_id_set.c fx_media_open.c fx_media_open_notify_set.c fx_media_read.c fx_media_space_available.c fx_media_volume_get.c fx_media_volume_get_extended.c fx_media_volume_set.c fx_media_write.c fx_partition_offset_calculate.c fx_ram_driver.c fx_system_date_get.c fx_system_date_set.c fx_system_initialize.c fx_system_time_get.c fx_system_time_set.c fx_system_timer_entry.c fx_trace_event_insert.c fx_trace_event_update.c fx_trace_object_register.c fx_trace_object_unregister.c fx_unicode_directory_create.c fx_unicode_directory_entry_change.c fx_unicode_directory_entry_read.c fx_unicode_directory_rename.c fx_unicode_directory_search.c fx_unicode_file_create.c fx_unicode_file_rename.c fx_unicode_length_get.c fx_unicode_length_get_extended.c fx_unicode_name_get.c fx_unicode_name_get_extended.c fx_unicode_short_name_get.c fx_unicode_short_name_get_extended.c fx_utility_16_unsigned_read.c fx_utility_16_unsigned_write.c fx_utility_32_unsigned_read.c fx_utility_32_unsigned_write.c fx_utility_64_unsigned_read.c fx_utility_64_unsigned_write.c fx_utility_absolute_path_get.c fx_utility_exFAT_allocate_new_cluster.c fx_utility_exFAT_bitmap_cache_prepare.c fx_utility_exFAT_bitmap_cache_update.c fx_utility_exFAT_bitmap_flush.c fx_utility_exFAT_bitmap_free_cluster_find.c fx_utility_exFAT_bitmap_initialize.c fx_utility_exFAT_bitmap_start_sector_get.c fx_utility_exFAT_cluster_free.c fx_utility_exFAT_cluster_state_get.c fx_utility_exFAT_cluster_state_set.c fx_utility_exFAT_geometry_check.c fx_utility_exFAT_name_hash_get.c fx_utility_exFAT_size_calculate.c fx_utility_exFAT_system_area_checksum_verify.c fx_utility_exFAT_system_area_checksum_write.c fx_utility_exFAT_system_area_format.c fx_utility_exFAT_system_sector_write.c fx_utility_exFAT_unicode_name_hash_get.c fx_utility_exFAT_upcase_table.c fx_utility_FAT_entry_read.c fx_utility_FAT_entry_write.c fx_utility_FAT_flush.c fx_utility_FAT_map_flush.c fx_utility_FAT_sector_get.c fx_utility_logical_sector_cache_entry_read.c fx_utility_logical_sector_flush.c fx_utility_logical_sector_read.c fx_utility_logical_sector_write.c fx_utility_memory_copy.c fx_utility_memory_set.c fx_utility_string_length_get.c fx_utility_token_length_get.c fxe_directory_attributes_read.c fxe_directory_attributes_set.c fxe_directory_create.c fxe_directory_default_get.c fxe_directory_default_get_copy.c fxe_directory_default_set.c fxe_directory_delete.c fxe_directory_first_entry_find.c fxe_directory_first_full_entry_find.c fxe_directory_information_get.c fxe_directory_local_path_clear.c fxe_directory_local_path_get.c fxe_directory_local_path_get_copy.c fxe_directory_local_path_restore.c fxe_directory_local_path_set.c fxe_directory_long_name_get.c fxe_directory_long_name_get_extended.c fxe_directory_name_test.c fxe_directory_next_entry_find.c fxe_directory_next_full_entry_find.c fxe_directory_rename.c fxe_directory_short_name_get.c fxe_directory_short_name_get_extended.c fxe_fault_tolerant_enable.c fxe_file_allocate.c fxe_file_attributes_read.c fxe_file_attributes_set.c fxe_file_best_effort_allocate.c fxe_file_close.c fxe_file_create.c fxe_file_date_time_set.c fxe_file_delete.c fxe_file_extended_allocate.c fxe_file_extended_best_effort_allocate.c fxe_file_extended_relative_seek.c fxe_file_extended_seek.c fxe_file_extended_truncate.c fxe_file_extended_truncate_release.c fxe_file_open.c fxe_file_read.c fxe_file_relative_seek.c fxe_file_rename.c fxe_file_seek.c fxe_file_truncate.c fxe_file_truncate_release.c fxe_file_write.c fxe_file_write_notify_set.c fxe_media_abort.c fxe_media_cache_invalidate.c fxe_media_check.c fxe_media_close.c fxe_media_close_notify_set.c fxe_media_exFAT_format.c fxe_media_extended_space_available.c fxe_media_flush.c fxe_media_format.c fxe_media_open.c fxe_media_open_notify_set.c fxe_media_read.c fxe_media_space_available.c fxe_media_volume_get.c fxe_media_volume_get_extended.c fxe_media_volume_set.c fxe_media_write.c fxe_system_date_get.c fxe_system_date_set.c fxe_system_time_get.c fxe_system_time_set.c fxe_unicode_directory_create.c fxe_unicode_directory_rename.c fxe_unicode_file_create.c fxe_unicode_file_rename.c fxe_unicode_name_get.c fxe_unicode_name_get_extended.c fxe_unicode_short_name_get.c fxe_unicode_short_name_get_extended.c
  group FILEX/Port
    ./Threadx_to_rt-thread/filex_port/: filex_dfs.c
  group threadx_to_rt
    ./Threadx_to_rt-thread/port/: threadx_to_rtthread.c
